# Keil uVision project stm32l4_bldc.uvprojx, settings and files
target stm32l4_bldc (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L452RETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20027FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: stm32l4_bldc
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L452xx
  c misc: --C99
  c include: ../Inc;        ../Drivers/STM32L4xx_HAL_Driver/Inc;        ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;        ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;        ../Drivers/CMSIS/Device/ST/STM32L4xx/Include;        ../Middlewares/Third_Party/FreeRTOS/Source/include;        ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;        ../Drivers/CMSIS/Include;        ..\MC_BLDC_Lib\Inc
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  link misc: --diag_suppress=L6329
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_flash_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_pwr.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_flash.c stm32l4xx_hal_dma.c stm32l4xx_hal_adc.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_uart.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: list.c timers.c queue.c event_groups.c tasks.c croutine.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Application/MDK-ARM
    ./: startup_stm32l452xx.s
  group Application/User
    ../Src/: stm32l4xx_it.c main.c stm32l4xx_hal_msp.c freertos.c adc.c usart.c gpio.c tim.c
  group MC_BLDC_Lib
    ../MC_BLDC_Lib/Src/: bldc_lib.c
software components: CMSIS:CORE 5.0.1
